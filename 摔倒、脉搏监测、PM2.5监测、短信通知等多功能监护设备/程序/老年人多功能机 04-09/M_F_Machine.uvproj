# Keil uVision project M_F_Machine.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: M_F_Machine +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: main.c GPIO.c Delays.c LCD.c ADXL345.c Uart.c DS1302.c Keyscan.c
